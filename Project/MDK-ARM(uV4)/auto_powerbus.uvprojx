# Keil uVision project auto_powerbus.uvprojx, settings and files
target Host (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: auto_powerbus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\app\inc;..\..\User\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../User/app/src/: main.c
    ../../User/app/inc/: bsp.h
  group BSP
    ../../User/bsp/src/: CRC_Funation.c GPIO_Funation.c NVIC_Funation.c TIM_Funation.c USART_Funation.c ZongZhiXin.c bsp_oled.c FLISH_Funation.c bsp_cpu_flash.c
    ../../User/app/src/: flash.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group MDK-ARM
    ../../Libraries/CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../../User/app/src/: system_stm32f10x.c
  group Doc
    ../../Doc/: 02.开发环境说明.txt 01.功能说明.txt
