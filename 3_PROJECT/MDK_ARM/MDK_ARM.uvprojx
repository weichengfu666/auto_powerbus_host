# Keil uVision project MDK_ARM.uvprojx, settings and files
target TEMPLATE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MDK_ARM +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\..\0_CORE;..\..\1_FWLIB_3_5_0;..\..\1_FWLIB_3_5_0\inc;..\..\1_FWLIB_3_5_0\src;..\MDK_ARM;..\..\3_PROJECT;..\..\4_FUNATION
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../../0_CORE/: startup_stm32f10x_hd.s core_cm3.c
  group USER
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB_3_5_0
    ../../1_FWLIB_3_5_0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group FUNATION
    ../../4_FUNATION/: GPIO_Funation.c NVIC_Funation.c TIM_Funation.c USART_Funation.c FLISH_Funation.c ZongZhiXin.c CRC_Funation.c
